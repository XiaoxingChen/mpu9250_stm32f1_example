# Keil uVision project IMU_AHRS.uvprojx, settings and files
target IMU_AHRS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IMU_AHRS +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,HARDWARE_1V7
  c include: .\StartUp;.\User_Src;.\Lib\inc;.\HardWareDriver;.\HardWareDriver\BMP180;.\HardWareDriver\HMC5883L;.\HardWareDriver\IMU;.\HardWareDriver\LED;.\HardWareDriver\MPU6050;.\HardWareDriver\UART2;.\HardWareDriver\UARTs;.\HardWareDriver\EEPROM;.\HardWareDriver\BMP085;.\HardWareDriver\EEPROM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./StartUp/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group HardWareDriver
    ./HardWareDriver/: IOI2C.c base_timer.c base_timer_wrapper.c
    ./HardWareDriver/HMC5883L/: HMC5883L.c
    ./HardWareDriver/IMU/: IMU.c
    ./HardWareDriver/LED/: LED.c
    ./HardWareDriver/MPU6050/: MPU6050.c
    ./HardWareDriver/UART2/: UART2.c
    ./HardWareDriver/UARTs/: UARTs.c
    ./HardWareDriver/BMP180/: BMP180.c
    ./HardWareDriver/EEPROM/: eeprom.c
  group User_Src
    ./User_Src/: main.c stm32f10x_it.c upload_state_machine.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
software components: CMSIS:CORE 5.1.2
